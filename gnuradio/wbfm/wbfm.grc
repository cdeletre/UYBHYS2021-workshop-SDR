options:
  parameters:
    generate_options: qt_gui
    id: wbfm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_decimation
  id: variable
  parameters:
    value: '40'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: f_ch0
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Ch0 (MHz)
    orient: Qt.Horizontal
    rangeType: int
    start: '87'
    step: '1'
    stop: '108'
    value: '100'
  states: {}
- name: f_lowpass
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,2,1,1
    label: Lowpass (kHz)
    orient: Qt.Horizontal
    rangeType: int
    start: '10'
    step: '10'
    stop: int(samp_rate/2e3)
    value: int(samp_rate/2e3)
  states: {}
- name: f_shift
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: Shift (kHz)
    orient: Qt.Horizontal
    rangeType: int
    start: '-900'
    step: '100'
    stop: '900'
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    label: Gain (dB)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '49'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_rate*audio_decimation
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decimation
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: audio_rate
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: f_shift*1e3
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_lowpass*1e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: f_lowpass*1e3/4
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: f_ch0*1e6
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 5,2,4,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 5,1,4,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,4,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
