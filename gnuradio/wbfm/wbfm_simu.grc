options:
  parameters:
    generate_options: qt_gui
    id: wbfm_simu
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_decimation
  id: variable
  parameters:
    value: '40'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: f_lowpass
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,2,1,1
    label: Lowpass (kHz)
    orient: Qt.Horizontal
    rangeType: int
    start: '10'
    step: '10'
    stop: int(samp_rate/2e3)
    value: int(samp_rate/2e3)
  states: {}
- name: f_shift
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: Shift (kHz)
    orient: Qt.Horizontal
    rangeType: int
    start: '-900'
    step: '100'
    stop: '900'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_rate*audio_decimation
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decimation
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: audio_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/user/gnuradio/wbfm/fm1.cs8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/gnuradio/wbfm/fm2.cs8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: f_shift*1e3
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: 200e3
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_lowpass*1e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: f_lowpass*1e3/4
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 5,2,4,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 5,1,4,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,4,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', rational_resampler_xxx_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', blocks_add_xx_0, '1']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
