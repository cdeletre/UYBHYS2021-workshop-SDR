options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: logitechex110_dual_simu
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: decimation_fir
  id: variable
  parameters:
    value: '5'
  states: {}
- name: decimation_nbfm
  id: variable
  parameters:
    value: '2'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 2.5e3
  states: {}
- name: fc0
  id: variable
  parameters:
    value: 27e6 + 93e3
  states: {}
- name: fc1
  id: variable
  parameters:
    value: 27e6 + 143e3
  states: {}
- name: fs
  id: variable
  parameters:
    value: 27.120e6
  states: {}
- name: output_rate
  id: variable
  parameters:
    value: int(samp_rate/(decimation_nbfm*decimation_fir))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate/baud_rate)/(decimation_nbfm*decimation_fir)
  states: {}
- name: symbol_duration
  id: variable
  parameters:
    value: 1.0/baud_rate
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: output_rate
    max_dev: deviation
    quad_rate: int(samp_rate/decimation_fir)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: output_rate
    max_dev: deviation
    quad_rate: int(samp_rate/decimation_fir)
    tau: '75e-6'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/user/gnuradio/logitechex110/gqrx_20180105_132052_27120000_240000_fc_password.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '9000'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '9001'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_bb_0
  id: digital_correlate_access_code_bb
  parameters:
    access_code: '0000000000111111111100000000001111111111'
    threshold: '1'
  states: {}
- name: digital_correlate_access_code_bb_0_0
  id: digital_correlate_access_code_bb
  parameters:
    access_code: '0000000000111111111100000000001111111111'
    threshold: '1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fc0-fs
    decim: decimation_fir
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,deviation*1.5,deviation/2.0)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fc1-fs
    decim: decimation_fir
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,deviation*1.5,deviation/2.0)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: fs
    fftsize: '512'
    gui_hint: wtab@1
    legend: 'False'
    showports: 'True'
    type: complex
    update_time: '0.2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: wtab@2
    label1: ''
    legend: 'False'
    size: '1024'
    srate: output_rate
    tr_level: '25'
    type: float
    update_time: '0.2'
    ylabel: Channel 0
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: wtab@3
    label1: ''
    legend: 'False'
    size: '1024'
    srate: output_rate
    tr_level: '0'
    type: float
    update_time: '0.2'
    ylabel: Channel 1
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: wtab@4
    label1: ''
    legend: 'False'
    size: '1024'
    srate: output_rate
    tr_level: '1.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.2'
    ylabel: Channel 0
    ymax: '10'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: wtab@5
    label1: ''
    legend: 'False'
    size: '1024'
    srate: output_rate
    tr_level: '1.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.2'
    ylabel: Channel 0
    ymax: '10'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fs
    fftsize: '512'
    gui_hint: wtab@0
    showports: 'True'
    type: complex
    update_time: '0.2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: wtab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,1,1,3
    label0: Waterfall
    label1: FFT
    label2: Demod channel 0
    label3: Demod channel 1
    label4: Logical channel 0
    label5: Logical channel 1
    num_tabs: '6'
  states: {}

connections:
- [analog_nbfm_rx_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_nbfm_rx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [analog_nbfm_rx_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_udp_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_bb_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_udp_sink_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_correlate_access_code_bb_0_0, '0']
- [digital_correlate_access_code_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_correlate_access_code_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_nbfm_rx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_nbfm_rx_0_0, '0']

metadata:
  file_format: 1
